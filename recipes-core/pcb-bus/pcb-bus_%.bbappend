# Change startup script to 11 (from default 01)
CONFIG_PCB_SYSBUS_LVL=11
